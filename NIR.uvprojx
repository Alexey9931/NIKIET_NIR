# Keil uVision project NIR.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: MDR1986BE4 Milandr
  pack: Keil.MDR1986BExx.1.5
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NIR
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c ADC.c ADC.h TIMER.c TIMER.h UART.c UART.h PORTS.c PORTS.h DATA_INTERFACE.c DATA_INTERFACE.h REGISTER_SPACE.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.5, Drivers:ADC 1.5, Drivers:PORT 1.5, Drivers:RST_CLK 1.5, Drivers:TIMER 1.5, Drivers:UART 1.5
